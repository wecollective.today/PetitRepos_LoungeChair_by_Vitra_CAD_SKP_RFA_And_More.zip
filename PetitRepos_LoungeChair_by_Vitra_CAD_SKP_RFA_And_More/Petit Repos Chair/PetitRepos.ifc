Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-01-11T13:11:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 11 13:11:35 2019 * Host: DESKTOP-PKIN6P4 * Database: C:\Users\Pichau\AppData\Local\Temp\{D4930D24-5174-4460-8645-BA4840338476}\ifc * Database version: 5507 * Database creation date: Fri Jan 11 13:11:34 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 11 13:11:34 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 11 13:11:34 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Petit Repos Chair, CONV_Vitra_DmstcChrs_PetitRepos:Petit Repos Chair:199215
In: Level 1
Material: Glide white, Aluminum, Leather Chocolate 68
Pset_ManufacturerTypeInformation - ModelReference: 21042500; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.38627 m2; Volume: 0.313814 m3
Materials and Finishes - ArmchairMainMaterial: Leather Chocolate 68; ArmchairSecondaryMaterial: Aluminum; ArmchairTertiaryMaterial: Glide white
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_PetitRepos: Petit Repos Chair; Family and Type: CONV_Vitra_DmstcChrs_PetitRepos: Petit Repos Chair; InstallationDate: n/a; Material: Aluminium, textile & polyurethane; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_PetitRepos: Petit Repos Chair; Type Id: CONV_Vitra_DmstcChrs_PetitRepos: Petit Repos Chair; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_PetitRepos; ConvergoRefNr: 0089-1812-0153-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Petit Repos is part of the Repos armchair family by Antonio Citterio. The backrest can be reclined and is generously padded, offering superb comfort despite the armchair's compact size. The armchair comes with covers in a choice of leather or fabric.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 18/12/2018
Identity Data(Type) - Collection: Petit Repos; Cost: 0; Description: Petit Repos is part of the Repos armchair family by Antonio Citterio. The backrest can be reclined and is generously padded, offering superb comfort despite the armchair's compact size. The armchair comes with covers in a choice of leather or fabric.; Designer: Antonio Citterio; Manufacturer: Vitra; Model: Petit Repos Chair; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/253300/storage/master/download/FS_Petit_Repos-EN_Preview-Single-Page.pdf; Type Name: Petit Repos Chair; URL: https://www.vitra.com/en-un/living/product/details/petit-repos
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_PetitRepos; Features: Seat heights: 405 mm (330 mm with applied load, measured in accordance with EN 1335-1) or 445 mm (370 mm with applied load, measured in accordance with EN 1335-1).; Finish: Chair/body: moulded polyurethane foam with plastic frame. Base: four-star swivel base in die-cast aluminium, polished or powder-coated finish.; Grade: n/a; ModelNumber: n/a; ModelReference: 21042500; Name: DmstcChrs_PetitRepos; ReplacementCost: n/a; Shape: Sculptured; Size: 665x660x715/755 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
